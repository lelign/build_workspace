inherit externalsrc
EXTERNALSRC = "/home/iru/poky-socfpga/build/workspace/recipes"
EXTERNALSRC_BUILD = "/home/iru/poky-socfpga/build/workspace/recipes"
